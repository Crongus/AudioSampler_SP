# IAR project STM32H7A3ZIT.ewp, settings and files
configuration STM32H7A3ZIT (ARM, debug)
  General.OGChipSelectEditMenu: STM32H7A3ZI ST STM32H7A3ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H7A3xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc; ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H7A3ZIT.hex
  ILINK.IlinkOutputFile: STM32H7A3ZIT.out
  ILINK.IlinkIcfFile: stm32h7a3xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32h7a3xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fmc.c i2c.c i2s.c memorymap.c spdifrx.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
