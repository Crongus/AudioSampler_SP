<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32MX_DevBoard.ewp</path>
  </project>
  <batchBuild />
</workspace>
